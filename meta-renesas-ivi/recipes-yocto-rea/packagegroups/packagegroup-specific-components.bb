DESCRIPTION = "REA utils package"
LICENSE = "CLOSED"

inherit packagegroup

PACKAGES = "\
    packagegroup-specific-components \
    "

RDEPENDS_packagegroup-specific-components = "\
	fbv \
	libungif \
    "
